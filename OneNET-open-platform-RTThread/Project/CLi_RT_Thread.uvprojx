# Keil uVision project CLi_RT_Thread.uvprojx, settings and files
target CLi_RT_Thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CLi_RT_Thread +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\rt-thread\components\finsh;..\rt-thread\include;..\rt-thread\include\libc;..\User;..\HARDWARE;..\SYSTEM;..\Sensor
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../User/: board.c main.c rtconfig.h stm32f10x_it.c deal_with.c test.c
  group DOC
    ../Doc/: readme.txt
  group HARDWARE
    ../HARDWARE/: beep.c fire.c key_exti.c led_test.c malloc.c relay.c wdg.c
  group rtt/source
    ../rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group rtt/ports
    ../rt-thread/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
  group SYSTEM
    ../SYSTEM/: delay.c sys.c usart.c
  group Sensor
    ../Sensor/: GeneralTim.c GP2Y10_adc.c HLK_LD2410C.c HLK_TX510.c ML302.c MQ2_adc.c oled.c SGP30.c SHT30.c timer_MQ2.c uart4.c uart5.c usart2.c usart3.c
