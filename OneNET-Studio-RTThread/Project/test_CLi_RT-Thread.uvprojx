# Keil uVision project test_CLi_RT-Thread.uvprojx, settings and files
target test_CLi_RT-Thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test_CLi_RT-Thread +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\rt-thread\components\finsh;..\rt-thread\include;..\rt-thread\include\libc;..\HARDWARE;..\Sensor\ASR PRO;..\Sensor\HLK-LD2410C;..\Sensor\HLK-TX510;..\Sensor\ML302;..\Sensor\OLED;..\Sensor\sensor_ADC;..\Sensor\SGP30;..\Sensor\SHT30
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../User/: main.c stm32f10x_it.c board.c GeneralTim.c deal_with.c test.c
  group DOC
    ../Doc/: readme.txt
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group rtt/source
    ../rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group rtt/ports
    ../rt-thread/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
  group HARDWARE
    ../HARDWARE/: led_test.c beep.c relay.c wdg.c bsp_key.c key_exti.c
  group Sensor
    ../Sensor/ASR PRO/: uart5.c
    ../Sensor/HLK-LD2410C/: HLK_LD2410C.c uart4.c
    ../Sensor/HLK-TX510/: HLK_TX510.c usart3.c
    ../Sensor/ML302/: ML302.c usart2.c
    ../Sensor/sensor_ADC/: GP2Y10_adc.c MQ2_adc.c timer_MQ2.c Fire_adc.c
    ../Sensor/OLED/: OLED_iic.c
    ../Sensor/SGP30/: SGP30_iic.c
    ../Sensor/SHT30/: SHT30_iic.c
